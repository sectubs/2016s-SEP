<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tun_source_test</value></param>
<param><key>author</key><value>Johannes Heidtmann</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>1. Create tun device by running  ../install_persistent_tun.sh
2. Run top_block
3. Send packets: nc -u 24.187.234.185 1337</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>tun_source Test</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>comment</key><value>Prints content of sent packets</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>comment</key><value>Prints length_tags /offsets inserted by tun_source</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>tun_source_debug</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>orcatun_tun_source_b</key>
<param><key>id</key><value>orcatun_tun_source_b_0</value></param>
<param><key>comment</key><value>'Use OT packets' controls IP-&gt;OT packet conversion</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>tun_name</key><value>"tun3"</value></param>
<param><key>use_ot_packets</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>orcatun_tun_source_b_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>orcatun_tun_source_b_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
